<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\DAQ_Embedded.ewp</path>
  </project>
  <batchBuild />
</workspace>
